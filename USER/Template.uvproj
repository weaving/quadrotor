# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,__FPU_USED=1,ARM_MATH_CM4,__FPU_PRESENT=1
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\DRIVER;..\HARDWARE;..\CONTROL;..\HARDWARE\EXTI;..\FWLIB\CMSIS\Include;..\HARDWARE\OV7670;..\HARDWARE\IWDG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/: 24l01.c Flash_eeprom.c HCSR04.c MPU6050.c TIMER.c HMC5883.c WFT_Controller.c MOTO.c OpticalFlow.c
    ../HARDWARE/OV7670/: sccb.c ov7670.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/IWDG/: iwdg.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group DRIVER
    ../DRIVER/: Data_Transfer.c i2c.c KalmanFilter.c PWM_Capture.c spi.c
  group CONTROL
    ../CONTROL/: CONTROL.c IMU.c PID.c
  group DSP-LIB
    ../FWLIB/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
